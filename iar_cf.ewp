# IAR project iar_cf.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303CC ST STM32F303CC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F30X_HD
  ICCARM.CCIncludePath2: APP; BSP; Libraries\CMSIS\CoreSupport; Libraries\CMSIS\DeviceSupport\startup; Libraries\CMSIS\DeviceSupport; Libraries\STM32F30x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: iar_cf.hex
  ILINK.IlinkOutputFile: iar_cf.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    APP/: main.c stm32f30x_it.c
  group BSP
    BSP/: bsp.c
  group CMSIS
    Libraries/CMSIS/DeviceSupport/: system_stm32f30x.c
  group STARTUP
    Libraries/CMSIS/DeviceSupport/startup/: startup_stm32f303xc.s
  group STMF303CC_LIB
    Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_fmc.c stm32f30x_gpio.c stm32f30x_hrtim.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
